# Keil uVision project Blink_led.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blink_led
  BeforeMake: $Stools\pio_all.bat
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  group Source Group 1
    ./: main.c startup.s
software components: CMSIS:CORE 6.1.1
